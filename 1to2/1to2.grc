options:
  parameters:
    generate_options: qt_gui
    id: ble_cs_1to2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: centetr_fre
  id: variable
  parameters:
    value: 2.44e9
  states: {}
- name: recv_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: send_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: start_button
  id: variable_qtgui_push_button
  parameters:
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: stop_button
  id: variable_qtgui_push_button
  parameters:
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: variable_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: 状态机独立时钟
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-49e6'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    showports: 'True'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_1
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_clock
  id: blocks_throttle2
  parameters:
    comment: 状态机时钟限速
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    bw0: 10e3
    bw1: 10e3
    center_freq0: centetr_fre
    center_freq1: centetr_fre
    dev_addr: '"addr=192.168.20.2"'
    dev_args: '"send_frame_size=8000,num_send_frames=512"'
    gain0: send_gain
    gain1: send_gain
    len_tag_name: ''
    nchan: '2'
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_sink_0_0_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: 10e3
    center_freq0: centetr_fre
    dev_addr: '"addr=192.168.10.2"'
    dev_args: '"send_frame_size=8000,num_send_frames=512"'
    gain0: send_gain
    len_tag_name: ''
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: centetr_fre
    center_freq1: centetr_fre
    dev_addr: '"addr=192.168.20.2"'
    dev_args: '"recv_frame_size=8000,num_recv_frames=512"'
    gain0: recv_gain
    gain1: recv_gain
    nchan: '2'
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: centetr_fre
    dev_addr: '"addr=192.168.10.2"'
    dev_args: '"recv_frame_size=8000,num_recv_frames=512"'
    gain0: recv_gain
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: sync
    type: fc32
  states: {}
- name: usrp_ble_data_send_0
  id: usrp_ble_data_send
  parameters:
    bit_duration: '0.001'
    sample_rate: samp_rate
  states: {}
- name: usrp_ble_data_send_0_0
  id: usrp_ble_data_send
  parameters:
    bit_duration: '0.001'
    sample_rate: samp_rate
  states: {}
- name: usrp_ble_data_store_0
  id: usrp_ble_data_store
  parameters:
    data_len: '200'
    path: /home/mess1ah/zz_ble_cs_gnuradio/1to2/data_reflector1_rx_from_initiator
    skip_len: '35000'
  states: {}
- name: usrp_ble_data_store_0_0
  id: usrp_ble_data_store
  parameters:
    data_len: '200'
    path: /home/mess1ah/zz_ble_cs_gnuradio/1to2/data_reflector2_rx_from_initiator
    skip_len: '35000'
  states: {}
- name: usrp_ble_data_store_0_1
  id: usrp_ble_data_store
  parameters:
    data_len: '200'
    path: /home/mess1ah/zz_ble_cs_gnuradio/1to2/data_initiator_rx_from_reflectors
    skip_len: '50000'
  states: {}
- name: usrp_ble_interact_center_0
  id: usrp_ble_interact_center
  parameters:
    repeat_total: '3'
    sample_rate: '100000000'
    start_btn: start_button
    stop_btn: stop_button
    use_msg_clock: 'False'
    wait_time_ms: '10'
  states: {}
- name: usrp_ble_random_phase_0
  id: usrp_ble_random_phase
  parameters:
    amplitude: '1.0'
    seed: '1'
  states: {}
- name: usrp_ble_random_phase_1
  id: usrp_ble_random_phase
  parameters:
    amplitude: '1.0'
    seed: '2'
  states: {}
- name: usrp_ble_random_phase_2
  id: usrp_ble_random_phase
  parameters:
    amplitude: '1.0'
    seed: '3'
  states: {}
- name: usrp_ble_tx_burst_gate_0
  id: usrp_ble_tx_burst_gate
  parameters:
    add_uhd_tags: 'True'
    burst_len: '100000'
    comment: 单个 gate 统一控制 initiator、reflector1、reflector2 三路发送
    num_channels: '3'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_clock, '0']
- [analog_sig_source_x_0_1, '0', usrp_ble_random_phase_0, '0']
- [analog_sig_source_x_0_1, '0', usrp_ble_random_phase_1, '0']
- [analog_sig_source_x_0_1, '0', usrp_ble_random_phase_2, '0']
- [blocks_multiply_conjugate_cc_0, '0', usrp_ble_data_store_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', usrp_ble_data_store_0_0, '0']
- [blocks_multiply_conjugate_cc_0_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_conjugate_cc_0_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_conjugate_cc_0_1, '0', usrp_ble_data_store_0_1, '0']
- [blocks_multiply_xx_0, '0', usrp_ble_tx_burst_gate_0, '0']
- [blocks_multiply_xx_0_0, '0', usrp_ble_tx_burst_gate_0, '1']
- [blocks_multiply_xx_0_1, '0', usrp_ble_tx_burst_gate_0, '2']
- [blocks_throttle_clock, '0', usrp_ble_interact_center_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [uhd_usrp_source_0, '1', blocks_multiply_conjugate_cc_0_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_multiply_conjugate_cc_0_1, '0']
- [usrp_ble_data_send_0, '0', blocks_multiply_xx_0, '1']
- [usrp_ble_data_send_0_0, '0', blocks_multiply_xx_0_0, '1']
- [usrp_ble_data_send_0_0, '0', blocks_multiply_xx_0_1, '1']
- [usrp_ble_interact_center_0, freq_ctrl, analog_sig_source_x_0_1, cmd]
- [usrp_ble_interact_center_0, freq_ctrl, blocks_message_debug_0, print]
- [usrp_ble_interact_center_0, freq_ctrl, usrp_ble_random_phase_0, freq]
- [usrp_ble_interact_center_0, freq_ctrl, usrp_ble_random_phase_1, freq]
- [usrp_ble_interact_center_0, freq_ctrl, usrp_ble_random_phase_2, freq]
- [usrp_ble_interact_center_0, send1_ctrl, usrp_ble_data_send_0, command]
- [usrp_ble_interact_center_0, send1_ctrl, usrp_ble_tx_burst_gate_0, command]
- [usrp_ble_interact_center_0, send2_ctrl, usrp_ble_data_send_0_0, command]
- [usrp_ble_interact_center_0, send2_ctrl, usrp_ble_tx_burst_gate_0, command]
- [usrp_ble_interact_center_0, store1_ctrl, usrp_ble_data_store_0, command]
- [usrp_ble_interact_center_0, store1_ctrl, usrp_ble_data_store_0_0, command]
- [usrp_ble_interact_center_0, store2_ctrl, usrp_ble_data_store_0_1, command]
- [usrp_ble_random_phase_0, '0', blocks_multiply_conjugate_cc_0_1, '1']
- [usrp_ble_random_phase_0, '0', blocks_multiply_xx_0, '0']
- [usrp_ble_random_phase_1, '0', blocks_multiply_conjugate_cc_0, '1']
- [usrp_ble_random_phase_1, '0', blocks_multiply_xx_0_0, '0']
- [usrp_ble_random_phase_2, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [usrp_ble_random_phase_2, '0', blocks_multiply_xx_0_1, '0']
- [usrp_ble_tx_burst_gate_0, '0', uhd_usrp_sink_0_0_0_0, '0']
- [usrp_ble_tx_burst_gate_0, '1', uhd_usrp_sink_0_0_0, '0']
- [usrp_ble_tx_burst_gate_0, '2', uhd_usrp_sink_0_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
