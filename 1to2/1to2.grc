options:
  parameters:
    generate_options: qt_gui
    id: ble_cs_1to2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: centetr_fre
  id: variable
  parameters:
    value: 2.44e9
  states: {}
- name: recv_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: repeat_total
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: send_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: start_button
  id: variable_qtgui_push_button
  parameters:
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: start_freq_index
  id: variable
  parameters:
    value: '-40'
  states: {}
- name: step_hz
  id: variable
  parameters:
    value: 1e5
  states: {}
- name: stop_button
  id: variable_qtgui_push_button
  parameters:
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: stop_freq_index
  id: variable
  parameters:
    value: '40'
  states: {}
- name: wait_time_ms
  id: variable
  parameters:
    value: '100'
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: start_freq_index*step_hz
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    showports: 'True'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_initiator_2m
  id: blocks_file_sink
  parameters:
    comment: Continuous initiator-side capture, 2m group.
    file: /home/ubuntu/zz_ble_cs_gnuradio/1to2/data_initiator_rx_from_reflectors_2m
    type: complex
  states: {}
- name: blocks_file_sink_initiator_4m
  id: blocks_file_sink
  parameters:
    comment: Continuous initiator-side capture, 4m group.
    file: /home/ubuntu/zz_ble_cs_gnuradio/1to2/data_initiator_rx_from_reflectors_4m
    type: complex
  states: {}
- name: blocks_file_sink_reflector1_2m
  id: blocks_file_sink
  parameters:
    comment: Continuous reflector1-side capture, 2m group.
    file: /home/ubuntu/zz_ble_cs_gnuradio/1to2/data_reflector1_rx_from_initiator_2m
    type: complex
  states: {}
- name: blocks_file_sink_reflector1_4m
  id: blocks_file_sink
  parameters:
    comment: Continuous reflector1-side capture, 4m group.
    file: /home/ubuntu/zz_ble_cs_gnuradio/1to2/data_reflector1_rx_from_initiator_4m
    type: complex
  states: {}
- name: blocks_file_sink_reflector2_2m
  id: blocks_file_sink
  parameters:
    comment: Continuous reflector2-side capture, 2m group.
    file: /home/ubuntu/zz_ble_cs_gnuradio/1to2/data_reflector2_rx_from_initiator_2m
    type: complex
  states: {}
- name: blocks_file_sink_reflector2_4m
  id: blocks_file_sink
  parameters:
    comment: Continuous reflector2-side capture, 4m group.
    file: /home/ubuntu/zz_ble_cs_gnuradio/1to2/data_reflector2_rx_from_initiator_4m
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_1
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: uhd_usrp_sink_0_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    bw0: 10e3
    bw1: 10e3
    center_freq0: centetr_fre
    center_freq1: centetr_fre
    dev_addr: '"addr=192.168.40.2"'
    dev_args: '"send_frame_size=8000,num_send_frames=512"'
    gain0: send_gain
    gain1: send_gain
    len_tag_name: ''
    nchan: '2'
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_sink_0_0_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: 10e3
    center_freq0: centetr_fre
    dev_addr: '"addr=192.168.30.2"'
    dev_args: '"send_frame_size=8000,num_send_frames=512"'
    gain0: send_gain
    len_tag_name: ''
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: centetr_fre
    center_freq1: centetr_fre
    dev_addr: '"addr=192.168.40.2"'
    dev_args: '"recv_frame_size=8000,num_recv_frames=512"'
    gain0: recv_gain
    gain1: recv_gain
    nchan: '2'
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: centetr_fre
    dev_addr: '"addr=192.168.30.2"'
    dev_args: '"recv_frame_size=8000,num_recv_frames=512"'
    gain0: recv_gain
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: sync
    type: fc32
  states: {}
- name: usrp_ble_capture_gate_initiator_2m
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate initiator stream, 2m group.
    group_index: '0'
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_initiator_4m
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate initiator stream, 4m group.
    group_index: '1'
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_reflector1_2m
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate reflector1 stream, 2m group.
    group_index: '0'
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_reflector1_4m
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate reflector1 stream, 4m group.
    group_index: '1'
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_reflector2_2m
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate reflector2 stream, 2m group.
    group_index: '0'
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_reflector2_4m
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate reflector2 stream, 4m group.
    group_index: '1'
    num_channels: '1'
  states: {}
- name: usrp_ble_data_send_0
  id: usrp_ble_data_send
  parameters:
    bit_duration: '0.001'
    sample_rate: samp_rate
  states: {}
- name: usrp_ble_data_send_0_0
  id: usrp_ble_data_send
  parameters:
    bit_duration: '0.001'
    sample_rate: samp_rate
  states: {}
- name: usrp_ble_interact_center_0
  id: usrp_ble_interact_center
  parameters:
    capture_groups: '2'
    repeat_total: repeat_total
    sample_rate: int(samp_rate)
    start_btn: start_button
    start_freq_index: start_freq_index
    step_hz: step_hz
    stop_btn: stop_button
    stop_freq_index: stop_freq_index
    use_msg_clock: 'False'
    wait_time_ms: wait_time_ms
  states: {}

connections:
- [analog_sig_source_x_0_1, '0', blocks_multiply_conjugate_cc_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_conjugate_cc_0_1, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_1, '0']
- [analog_sig_source_x_0_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', usrp_ble_capture_gate_reflector1_2m, '0']
- [blocks_multiply_conjugate_cc_0, '0', usrp_ble_capture_gate_reflector1_4m, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', usrp_ble_capture_gate_reflector2_2m, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', usrp_ble_capture_gate_reflector2_4m, '0']
- [blocks_multiply_conjugate_cc_0_1, '0', usrp_ble_capture_gate_initiator_2m, '0']
- [blocks_multiply_conjugate_cc_0_1, '0', usrp_ble_capture_gate_initiator_4m, '0']
- [blocks_multiply_xx_0, '0', uhd_usrp_sink_0_0_0_0, '0']
- [blocks_multiply_xx_0_0, '0', uhd_usrp_sink_0_0_0, '0']
- [blocks_multiply_xx_0_1, '0', uhd_usrp_sink_0_0_0, '1']
- [uhd_usrp_source_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [uhd_usrp_source_0, '1', blocks_multiply_conjugate_cc_0_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_multiply_conjugate_cc_0_1, '0']
- [usrp_ble_capture_gate_initiator_2m, '0', blocks_file_sink_initiator_2m, '0']
- [usrp_ble_capture_gate_initiator_4m, '0', blocks_file_sink_initiator_4m, '0']
- [usrp_ble_capture_gate_reflector1_2m, '0', blocks_file_sink_reflector1_2m, '0']
- [usrp_ble_capture_gate_reflector1_4m, '0', blocks_file_sink_reflector1_4m, '0']
- [usrp_ble_capture_gate_reflector2_2m, '0', blocks_file_sink_reflector2_2m, '0']
- [usrp_ble_capture_gate_reflector2_4m, '0', blocks_file_sink_reflector2_4m, '0']
- [usrp_ble_data_send_0, '0', blocks_multiply_xx_0, '1']
- [usrp_ble_data_send_0, '0', usrp_ble_interact_center_0, '0']
- [usrp_ble_data_send_0_0, '0', blocks_multiply_xx_0_0, '1']
- [usrp_ble_data_send_0_0, '0', blocks_multiply_xx_0_1, '1']
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_initiator_2m, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_initiator_4m, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_reflector1_2m, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_reflector1_4m, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_reflector2_2m, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_reflector2_4m, command]
- [usrp_ble_interact_center_0, freq_ctrl, analog_sig_source_x_0_1, cmd]
- [usrp_ble_interact_center_0, freq_ctrl, blocks_message_debug_0, print]
- [usrp_ble_interact_center_0, send1_ctrl, usrp_ble_data_send_0, command]
- [usrp_ble_interact_center_0, send2_ctrl, usrp_ble_data_send_0_0, command]

metadata:
  file_format: 1
  grc_version: 3.10.7.0
