options:
  parameters:
    author: lfy
    description: USRP scope capture for BLE Channel Sounding IQ
    generate_options: qt_gui
    id: usrp_ble_scope
    output_language: python
    title: USRP BLE CS Scope
  states: {}

blocks:
- name: capture_samples
  id: variable
  parameters:
    value: int(samp_rate * capture_seconds)
  states: {}
- name: capture_seconds
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2.44e9
  states: {}
- name: recv_gain
  id: variable_qtgui_range
  parameters:
    label: recv_gain
    start: '0'
    step: '1'
    stop: '40'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/usrp_ble_scope/ble_cs_scope_ch0.c64
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: capture_samples
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '8192'
    grid: 'True'
    label1: IQ
    name: '"Frequency"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: '|IQ|'
    name: '"Amplitude / Burst"'
    size: '4096'
    srate: samp_rate
    type: float
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '4096'
    grid: 'True'
    label1: IQ
    name: '"Waterfall / Hopping"'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    dev_addr: '"addr=192.168.30.2"'
    dev_args: '"recv_frame_size=8000"'
    gain0: recv_gain
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_0, '0']
- [uhd_usrp_source_0, '0', blocks_head_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
