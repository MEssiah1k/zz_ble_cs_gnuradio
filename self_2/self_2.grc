options:
  parameters:
    generate_options: qt_gui
    id: ble_cs_self_2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: centetr_fre
  id: variable
  parameters:
    value: 2.44e9
  states: {}
- name: distance_m_1
  id: variable
  parameters:
    value: '2'
  states: {}
- name: distance_m_2
  id: variable
  parameters:
    value: '5'
  states: {}
- name: recv_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: send_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: start_button
  id: variable_qtgui_push_button
  parameters:
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: stop_button
  id: variable_qtgui_push_button
  parameters:
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: 状态机独立时钟，不能接在 burst gate 后面
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-49e6'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    showports: 'True'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_reflectors_at_initiator
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_i_rx
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_r1_rx
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_r2_rx
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_xx_i_tx
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_r1_tx
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_r2_tx
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_clock
  id: blocks_throttle2
  parameters:
    comment: 状态机时钟限速
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '4096'
    srate: samp_rate
    type: complex
  states: {}
- name: usrp_ble_channel_phase_i_to_r1
  id: usrp_ble_channel_phase
  parameters:
    amplitude: '1.0'
    center_freq_hz: centetr_fre
    distance_m: distance_m_1
  states: {}
- name: usrp_ble_channel_phase_i_to_r2
  id: usrp_ble_channel_phase
  parameters:
    amplitude: '1.0'
    center_freq_hz: centetr_fre
    distance_m: distance_m_2
  states: {}
- name: usrp_ble_channel_phase_r1_to_i
  id: usrp_ble_channel_phase
  parameters:
    amplitude: '1.0'
    center_freq_hz: centetr_fre
    distance_m: distance_m_1
  states: {}
- name: usrp_ble_channel_phase_r2_to_i
  id: usrp_ble_channel_phase
  parameters:
    amplitude: '1.0'
    center_freq_hz: centetr_fre
    distance_m: distance_m_2
  states: {}
- name: usrp_ble_data_send_0
  id: usrp_ble_data_send
  parameters:
    bit_duration: '0.001'
    sample_rate: samp_rate
  states: {}
- name: usrp_ble_data_send_0_0
  id: usrp_ble_data_send
  parameters:
    bit_duration: '0.001'
    sample_rate: samp_rate
  states: {}
- name: usrp_ble_data_store_0_0_0
  id: usrp_ble_data_store
  parameters:
    data_len: '200'
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/self_2/data_reflector2_rx_from_initiator
    skip_len: '35000'
  states: {}
- name: usrp_ble_data_store_0_1
  id: usrp_ble_data_store
  parameters:
    data_len: '200'
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/self_2/data_reflector1_rx_from_initiator
    skip_len: '35000'
  states: {}
- name: usrp_ble_data_store_0_2
  id: usrp_ble_data_store
  parameters:
    data_len: '200'
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/self_2/data_initiator_rx_from_reflectors
    skip_len: '50000'
  states: {}
- name: usrp_ble_interact_center_0
  id: usrp_ble_interact_center
  parameters:
    repeat_total: '3'
    sample_rate: '100000000'
    start_btn: start_button
    start_freq_index: '-40'
    stop_btn: stop_button
    stop_freq_index: '40'
    step_hz: 1e6
    use_msg_clock: 'False'
    wait_time_ms: '10'
  states: {}
- name: usrp_ble_random_phase_0
  id: usrp_ble_random_phase
  parameters:
    amplitude: '1.0'
    seed: '1'
  states: {}
- name: usrp_ble_random_phase_1
  id: usrp_ble_random_phase
  parameters:
    amplitude: '1.0'
    seed: '2'
  states: {}
- name: usrp_ble_random_phase_2
  id: usrp_ble_random_phase
  parameters:
    amplitude: '1.0'
    seed: '3'
  states: {}
- name: usrp_ble_tx_burst_gate_0
  id: usrp_ble_tx_burst_gate
  parameters:
    add_uhd_tags: 'True'
    burst_len: '80000'
    comment: 单个 gate 统一控制 initiator、reflector1、reflector2 三路发送
    num_channels: '3'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_clock, '0']
- [analog_sig_source_x_0_1, '0', usrp_ble_random_phase_0, '0']
- [analog_sig_source_x_0_1, '0', usrp_ble_random_phase_1, '0']
- [analog_sig_source_x_0_1, '0', usrp_ble_random_phase_2, '0']
- [blocks_add_xx_reflectors_at_initiator, '0', blocks_multiply_conjugate_cc_i_rx, '0']
- [blocks_multiply_conjugate_cc_i_rx, '0', usrp_ble_data_store_0_2, '0']
- [blocks_multiply_conjugate_cc_r1_rx, '0', usrp_ble_data_store_0_1, '0']
- [blocks_multiply_conjugate_cc_r2_rx, '0', usrp_ble_data_store_0_0_0, '0']
- [blocks_multiply_xx_i_tx, '0', usrp_ble_tx_burst_gate_0, '0']
- [blocks_multiply_xx_r1_tx, '0', usrp_ble_tx_burst_gate_0, '1']
- [blocks_multiply_xx_r2_tx, '0', usrp_ble_tx_burst_gate_0, '2']
- [blocks_throttle_0, '0', blocks_multiply_xx_i_tx, '1']
- [blocks_throttle_0_0, '0', blocks_multiply_xx_r1_tx, '1']
- [blocks_throttle_0_0, '0', blocks_multiply_xx_r2_tx, '1']
- [blocks_throttle_clock, '0', usrp_ble_interact_center_0, '0']
- [usrp_ble_channel_phase_i_to_r1, '0', blocks_multiply_conjugate_cc_r1_rx, '0']
- [usrp_ble_channel_phase_i_to_r2, '0', blocks_multiply_conjugate_cc_r2_rx, '0']
- [usrp_ble_channel_phase_r1_to_i, '0', blocks_add_xx_reflectors_at_initiator, '0']
- [usrp_ble_channel_phase_r2_to_i, '0', blocks_add_xx_reflectors_at_initiator, '1']
- [usrp_ble_data_send_0, '0', blocks_throttle_0, '0']
- [usrp_ble_data_send_0_0, '0', blocks_throttle_0_0, '0']
- [usrp_ble_interact_center_0, freq_ctrl, analog_sig_source_x_0_1, cmd]
- [usrp_ble_interact_center_0, freq_ctrl, blocks_message_debug_0, print]
- [usrp_ble_interact_center_0, freq_ctrl, usrp_ble_channel_phase_i_to_r1, freq]
- [usrp_ble_interact_center_0, freq_ctrl, usrp_ble_channel_phase_i_to_r2, freq]
- [usrp_ble_interact_center_0, freq_ctrl, usrp_ble_channel_phase_r1_to_i, freq]
- [usrp_ble_interact_center_0, freq_ctrl, usrp_ble_channel_phase_r2_to_i, freq]
- [usrp_ble_interact_center_0, freq_ctrl, usrp_ble_random_phase_0, freq]
- [usrp_ble_interact_center_0, freq_ctrl, usrp_ble_random_phase_1, freq]
- [usrp_ble_interact_center_0, freq_ctrl, usrp_ble_random_phase_2, freq]
- [usrp_ble_interact_center_0, send1_ctrl, usrp_ble_data_send_0, command]
- [usrp_ble_interact_center_0, send1_ctrl, usrp_ble_tx_burst_gate_0, command]
- [usrp_ble_interact_center_0, send2_ctrl, usrp_ble_data_send_0_0, command]
- [usrp_ble_interact_center_0, send2_ctrl, usrp_ble_tx_burst_gate_0, command]
- [usrp_ble_interact_center_0, store1_ctrl, usrp_ble_data_store_0_0_0, command]
- [usrp_ble_interact_center_0, store1_ctrl, usrp_ble_data_store_0_1, command]
- [usrp_ble_interact_center_0, store2_ctrl, usrp_ble_data_store_0_2, command]
- [usrp_ble_random_phase_0, '0', blocks_multiply_conjugate_cc_i_rx, '1']
- [usrp_ble_random_phase_0, '0', blocks_multiply_xx_i_tx, '0']
- [usrp_ble_random_phase_1, '0', blocks_multiply_conjugate_cc_r1_rx, '1']
- [usrp_ble_random_phase_1, '0', blocks_multiply_xx_r1_tx, '0']
- [usrp_ble_random_phase_2, '0', blocks_multiply_conjugate_cc_r2_rx, '1']
- [usrp_ble_random_phase_2, '0', blocks_multiply_xx_r2_tx, '0']
- [usrp_ble_tx_burst_gate_0, '0', qtgui_freq_sink_x_0, '0']
- [usrp_ble_tx_burst_gate_0, '0', qtgui_time_sink_x_0, '0']
- [usrp_ble_tx_burst_gate_0, '0', usrp_ble_channel_phase_i_to_r1, '0']
- [usrp_ble_tx_burst_gate_0, '0', usrp_ble_channel_phase_i_to_r2, '0']
- [usrp_ble_tx_burst_gate_0, '1', usrp_ble_channel_phase_r1_to_i, '0']
- [usrp_ble_tx_burst_gate_0, '2', usrp_ble_channel_phase_r2_to_i, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
