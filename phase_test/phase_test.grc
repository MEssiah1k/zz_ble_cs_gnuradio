options:
  parameters:
    author: OpenAI
    comment: Dual-channel TX/RX phase cancellation experiment. Compute rx0 / rx1 and inspect phase.
    generate_options: qt_gui
    id: phase_test
    output_language: python
    title: Dual RX Phase Divide Test
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    comment: Same RF center for both TX and both RX channels.
    value: 2.44e9
  states: {}
- name: recv_gain
  id: variable_qtgui_range
  parameters:
    label: recv_gain
    start: '0'
    step: '1'
    stop: '40'
    value: '18'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: send_gain
  id: variable_qtgui_range
  parameters:
    label: send_gain
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: tone_freq
  id: variable
  parameters:
    comment: Baseband TX tone. Set to 0 for DC, or 100e3 for non-DC.
    value: 100e3
  states: {}
- name: tx_amp
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: usrp_addr
  id: variable
  parameters:
    comment: Modify this if your device address is different.
    value: '"addr=192.168.30.2"'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: tx_amp
    comment: Same complex tone is transmitted on both TX channels.
    freq: tone_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters:
    comment: Phase of rx0 / rx1.
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    comment: rx0 / rx1. If common phase is shared, it should largely cancel here.
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    comment: Constellation of rx0 / rx1.
    grid: 'True'
    label1: quotient
    marker1: '-1'
    name: '"RX0 over RX1 Constellation"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Two raw RX channels.
    grid: 'True'
    label1: rx0
    label2: rx1
    name: '"RX Time"'
    nconnections: '2'
    size: '4096'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Wrapped phase of rx0 / rx1.
    grid: 'True'
    label1: angle(rx0/rx1)
    name: '"Phase Difference"'
    size: '4096'
    srate: samp_rate
    type: float
    ylabel: Phase (rad)
    ymax: '3.3'
    ymin: '-3.3'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: center_freq
    center_freq1: center_freq
    dev_addr: usrp_addr
    dev_args: '"send_frame_size=8000,num_send_frames=512"'
    gain0: send_gain
    gain1: send_gain
    nchan: '2'
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: center_freq
    center_freq1: center_freq
    dev_addr: usrp_addr
    dev_args: '"recv_frame_size=8000,num_recv_frames=512"'
    gain0: recv_gain
    gain1: recv_gain
    nchan: '2'
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '1']
- [blocks_complex_to_arg_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_divide_xx_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_divide_xx_0, '0', qtgui_const_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_divide_xx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '1', blocks_divide_xx_0, '1']
- [uhd_usrp_source_0, '1', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
