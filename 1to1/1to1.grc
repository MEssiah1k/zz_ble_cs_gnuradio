options:
  parameters:
    author: lfy
    generate_options: qt_gui
    id: ble_cs_1to1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: centetr_fre
  id: variable
  parameters:
    value: 2.44e9
  states: {}
- name: recv_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: repeat_total
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: send_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: start_button
  id: variable_qtgui_push_button
  parameters:
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: start_freq_index
  id: variable
  parameters:
    value: '-40'
  states: {}
- name: step_hz
  id: variable
  parameters:
    value: 1e5
  states: {}
- name: stop_button
  id: variable_qtgui_push_button
  parameters:
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: stop_freq_index
  id: variable
  parameters:
    value: '40'
  states: {}
- name: wait_time_ms
  id: variable
  parameters:
    value: '20'
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: start_freq_index*step_hz
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Continuous reflector-side capture.
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1/data_reflector_rx_from_initiator_calibration
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    comment: Continuous initiator-side capture.
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1/data_initiator_rx_from_reflector_calibration
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    comment: Continuous reflector-side capture, second sweep group.
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1/data_reflector_rx_from_initiator_measurement
    type: complex
  states: {}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    comment: Continuous initiator-side capture, second sweep group.
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1/data_initiator_rx_from_reflector_measurement
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: snippet_auto_stop
  id: snippet
  parameters:
    code: |-
      self._auto_stop_timer = QtCore.QTimer(self)
      self._auto_stop_timer.setSingleShot(True)

      def _auto_stop_flowgraph():
          self.stop()
          self.wait()
          self.close()

      self._auto_stop_timer.timeout.connect(_auto_stop_flowgraph)
      self._set_start_button_before_auto_stop = self.set_start_button

      def _set_start_button_with_auto_stop(start_button):
          self._set_start_button_before_auto_stop(start_button)
          if int(start_button):
              freq_count = abs(int(self.stop_freq_index) - int(self.start_freq_index)) + 1
              duration_ms = int(freq_count * int(self.repeat_total) * 2 * float(self.wait_time_ms) + 1000.0)
              self._auto_stop_timer.start(max(duration_ms, 1000))

      self.set_start_button = _set_start_button_with_auto_stop
    section: init_before_blocks
  states: {state: disabled}
- name: uhd_usrp_sink_0_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: 100e6
    center_freq0: centetr_fre
    dev_addr: '"addr=192.168.30.2"'
    dev_args: '"send_frame_size=8000,num_send_frames=512"'
    gain0: send_gain
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_0_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: centetr_fre
    center_freq1: centetr_fre
    dev_addr: '"addr=192.168.30.2"'
    dev_args: '"send_frame_size=8000,num_send_frames=512"'
    gain0: send_gain
    gain1: send_gain
    nchan: '2'
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: centetr_fre
    dev_addr: '"addr=192.168.30.2"'
    dev_args: '"recv_frame_size=8000,num_recv_frames=512"'
    gain0: recv_gain
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: centetr_fre
    center_freq1: centetr_fre
    dev_addr: '"addr=192.168.30.2"'
    dev_args: '"recv_frame_size=8000,num_recv_frames=512"'
    gain0: recv_gain
    gain1: recv_gain
    nchan: '2'
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: sync
    type: fc32
  states: {}
- name: usrp_ble_capture_gate_0
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate reflector stream before continuous file sink.
    group_index: '0'
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_0_0
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate initiator stream before continuous file sink.
    group_index: '0'
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_1
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate reflector stream for continuous capture group 2.
    group_index: '1'
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_1_0
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate initiator stream for continuous capture group 2.
    group_index: '1'
    num_channels: '1'
  states: {}
- name: usrp_ble_data_send_0
  id: usrp_ble_data_send
  parameters:
    bit_duration: '0.001'
    sample_rate: samp_rate
  states: {}
- name: usrp_ble_data_send_0_0
  id: usrp_ble_data_send
  parameters:
    bit_duration: '0.001'
    sample_rate: samp_rate
  states: {}
- name: usrp_ble_data_store_initiator_calibration
  id: usrp_ble_data_store
  parameters:
    capture_group_filter: '0'
    data_len: int(200e0)
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1/calibration/data_initiator_rx_from_reflector
    skip_len: int(60/1000*samp_rate)
  states: {state: disabled}
- name: usrp_ble_data_store_initiator_measurement
  id: usrp_ble_data_store
  parameters:
    capture_group_filter: '1'
    data_len: int(200e0)
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1/measurement/data_initiator_rx_from_reflector
    skip_len: int(60/1000*samp_rate)
  states: {state: disabled}
- name: usrp_ble_data_store_reflector_calibration
  id: usrp_ble_data_store
  parameters:
    capture_group_filter: '0'
    data_len: int(200e0)
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1/calibration/data_reflector_rx_from_initiator
    skip_len: int(60/1000*samp_rate)
  states: {state: disabled}
- name: usrp_ble_data_store_reflector_measurement
  id: usrp_ble_data_store
  parameters:
    capture_group_filter: '1'
    data_len: int(200e0)
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1/measurement/data_reflector_rx_from_initiator
    skip_len: int(60/1000*samp_rate)
  states: {state: disabled}
- name: usrp_ble_interact_center_0
  id: usrp_ble_interact_center
  parameters:
    capture_groups: '2'
    repeat_total: repeat_total
    rx_tail_time_ms: '50'
    sample_rate: int(samp_rate)
    start_btn: start_button
    start_freq_index: start_freq_index
    step_hz: step_hz
    stop_btn: stop_button
    stop_freq_index: stop_freq_index
    use_msg_clock: 'False'
    wait_time_ms: wait_time_ms
  states: {}

connections:
- [analog_sig_source_x_0_1, '0', blocks_multiply_conjugate_cc_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_0_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', usrp_ble_capture_gate_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', usrp_ble_capture_gate_1, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', usrp_ble_capture_gate_0_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', usrp_ble_capture_gate_1_0, '0']
- [blocks_multiply_xx_0, '0', uhd_usrp_sink_0_0_0_0, '0']
- [blocks_multiply_xx_0_0, '0', uhd_usrp_sink_0_0_0_0, '1']
- [uhd_usrp_source_0_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [uhd_usrp_source_0_0, '1', blocks_multiply_conjugate_cc_0, '0']
- [usrp_ble_capture_gate_0, '0', blocks_file_sink_0, '0']
- [usrp_ble_capture_gate_0, '0', usrp_ble_data_store_reflector_calibration, '0']
- [usrp_ble_capture_gate_0_0, '0', blocks_file_sink_0_0, '0']
- [usrp_ble_capture_gate_0_0, '0', usrp_ble_data_store_initiator_calibration, '0']
- [usrp_ble_capture_gate_1, '0', blocks_file_sink_1, '0']
- [usrp_ble_capture_gate_1, '0', usrp_ble_data_store_reflector_measurement, '0']
- [usrp_ble_capture_gate_1_0, '0', blocks_file_sink_1_0, '0']
- [usrp_ble_capture_gate_1_0, '0', usrp_ble_data_store_initiator_measurement, '0']
- [usrp_ble_data_send_0, '0', blocks_multiply_xx_0, '1']
- [usrp_ble_data_send_0, '0', usrp_ble_interact_center_0, '0']
- [usrp_ble_data_send_0_0, '0', blocks_multiply_xx_0_0, '1']
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_0, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_0_0, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_1, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_1_0, command]
- [usrp_ble_interact_center_0, freq_ctrl, analog_sig_source_x_0_1, cmd]
- [usrp_ble_interact_center_0, freq_ctrl, blocks_message_debug_0, print]
- [usrp_ble_interact_center_0, send1_ctrl, usrp_ble_data_send_0, command]
- [usrp_ble_interact_center_0, send2_ctrl, usrp_ble_data_send_0_0, command]
- [usrp_ble_interact_center_0, store1_ctrl, usrp_ble_data_store_reflector_calibration, command]
- [usrp_ble_interact_center_0, store1_ctrl, usrp_ble_data_store_reflector_measurement, command]
- [usrp_ble_interact_center_0, store2_ctrl, usrp_ble_data_store_initiator_calibration, command]
- [usrp_ble_interact_center_0, store2_ctrl, usrp_ble_data_store_initiator_measurement, command]

metadata:
  file_format: 1
