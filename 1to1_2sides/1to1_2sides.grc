options:
  parameters:
    author: lfy
    generate_options: qt_gui
    id: ble_cs_1to1_2sides
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: centetr_fre
  id: variable
  parameters:
    value: 2.44e9
  states: {}
- name: recv_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '20'
    value: '1'
  states: {}
- name: repeat_total
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: send_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '20'
    value: '1'
  states: {}
- name: start_button
  id: variable_qtgui_push_button
  parameters:
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: start_freq_index
  id: variable
  parameters:
    value: '-40'
  states: {}
- name: step_hz
  id: variable
  parameters:
    value: 1e5
  states: {}
- name: stop_button
  id: variable_qtgui_push_button
  parameters:
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: stop_freq_index
  id: variable
  parameters:
    value: '40'
  states: {}
- name: wait_time_ms
  id: variable
  parameters:
    value: '50'
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: start_freq_index*step_hz
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Continuous reflector-side capture.
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_reflector_rx_from_initiator_calibration
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    comment: Continuous initiator-side capture.
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_initiator_rx_from_reflector_calibration
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    comment: Continuous reflector-side capture, second sweep group.
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_reflector_rx_from_initiator_measurement
    type: complex
  states: {}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    comment: Continuous initiator-side capture, second sweep group.
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_initiator_rx_from_reflector_measurement
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: snippet_auto_stop
  id: snippet
  parameters:
    code: |-
      self._auto_stop_timer = QtCore.QTimer(self)
      self._auto_stop_timer.setSingleShot(True)

      def _auto_stop_flowgraph():
          self.stop()
          self.wait()
          self.close()

      self._auto_stop_timer.timeout.connect(_auto_stop_flowgraph)
      self._set_start_button_before_auto_stop = self.set_start_button

      def _set_start_button_with_auto_stop(start_button):
          self._set_start_button_before_auto_stop(start_button)
          if int(start_button):
              freq_count = abs(int(self.stop_freq_index) - int(self.start_freq_index)) + 1
              duration_ms = int(freq_count * int(self.repeat_total) * 2 * float(self.wait_time_ms) + 1000.0)
              self._auto_stop_timer.start(max(duration_ms, 1000))

      self.set_start_button = _set_start_button_with_auto_stop
    section: init_before_blocks
  states: {state: disabled}
- name: uhd_usrp_sink_0_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: centetr_fre
    clock_source0: external
    dev_addr: '"addr=192.168.30.2"'
    dev_args: '"send_frame_size=8000,num_send_frames=512"'
    gain0: send_gain
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_sink_0_0_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: centetr_fre
    dev_addr: '"addr=192.168.40.2"'
    dev_args: '"send_frame_size=8000,num_send_frames=512"'
    gain0: send_gain
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: centetr_fre
    clock_source0: external
    dev_addr: '"addr=192.168.30.2"'
    dev_args: '"recv_frame_size=8000,num_recv_frames=512"'
    gain0: recv_gain
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: centetr_fre
    dev_addr: '"addr=192.168.40.2"'
    dev_args: '"recv_frame_size=8000,num_recv_frames=512"'
    gain0: recv_gain
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: sync
    type: fc32
  states: {}
- name: usrp_ble_capture_gate_0
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate reflector stream before continuous file sink.
    group_index: '0'
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_0_0
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate initiator stream before continuous file sink.
    group_index: '0'
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_1
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate reflector stream for continuous capture group 2.
    group_index: '1'
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_1_0
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate initiator stream for continuous capture group 2.
    group_index: '1'
    num_channels: '1'
  states: {}
- name: usrp_ble_data_send_0
  id: usrp_ble_data_send
  parameters:
    bit_duration: '0.001'
    sample_rate: samp_rate
  states: {}
- name: usrp_ble_data_send_0_0
  id: usrp_ble_data_send
  parameters:
    bit_duration: '0.001'
    sample_rate: samp_rate
  states: {}
- name: usrp_ble_data_store_0
  id: usrp_ble_data_store
  parameters:
    data_len: '200000'
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_reflector_rx_from_initiator
    skip_len: int(0/1000*samp_rate)
  states: {state: disabled}
- name: usrp_ble_data_store_0_0
  id: usrp_ble_data_store
  parameters:
    data_len: '200000'
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_initiator_rx_from_reflector
    skip_len: int(0/1000*samp_rate)
  states: {state: disabled}
- name: usrp_ble_interact_center_0
  id: usrp_ble_interact_center
  parameters:
    capture_groups: '9'
    repeat_total: repeat_total
    sample_rate: int(samp_rate)
    start_btn: start_button
    start_freq_index: start_freq_index
    step_hz: step_hz
    stop_btn: stop_button
    stop_freq_index: stop_freq_index
    use_msg_clock: 'False'
    wait_time_ms: wait_time_ms
  states: {}
- name: blocks_file_sink_4
  id: blocks_file_sink
  parameters:
    comment: Continuous reflector-side capture, group 2.
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_reflector_rx_from_initiator_measurement_2
    type: complex
  states: {}
- name: blocks_file_sink_5
  id: blocks_file_sink
  parameters:
    comment: Continuous initiator-side capture, group 2.
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_initiator_rx_from_reflector_measurement_2
    type: complex
  states: {}
- name: blocks_file_sink_6
  id: blocks_file_sink
  parameters:
    comment: Continuous reflector-side capture, group 3.
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_reflector_rx_from_initiator_measurement_3
    type: complex
  states: {}
- name: blocks_file_sink_7
  id: blocks_file_sink
  parameters:
    comment: Continuous initiator-side capture, group 3.
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_initiator_rx_from_reflector_measurement_3
    type: complex
  states: {}
- name: blocks_file_sink_8
  id: blocks_file_sink
  parameters:
    comment: Continuous reflector-side capture, group 4.
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_reflector_rx_from_initiator_measurement_4
    type: complex
  states: {}
- name: blocks_file_sink_9
  id: blocks_file_sink
  parameters:
    comment: Continuous initiator-side capture, group 4.
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_initiator_rx_from_reflector_measurement_4
    type: complex
  states: {}
- name: blocks_file_sink_10
  id: blocks_file_sink
  parameters:
    comment: Continuous reflector-side capture, group 5.
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_reflector_rx_from_initiator_measurement_5
    type: complex
  states: {}
- name: blocks_file_sink_11
  id: blocks_file_sink
  parameters:
    comment: Continuous initiator-side capture, group 5.
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_initiator_rx_from_reflector_measurement_5
    type: complex
  states: {}
- name: blocks_file_sink_12
  id: blocks_file_sink
  parameters:
    comment: Continuous reflector-side capture, group 6.
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_reflector_rx_from_initiator_measurement_6
    type: complex
  states: {}
- name: blocks_file_sink_13
  id: blocks_file_sink
  parameters:
    comment: Continuous initiator-side capture, group 6.
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_initiator_rx_from_reflector_measurement_6
    type: complex
  states: {}
- name: blocks_file_sink_14
  id: blocks_file_sink
  parameters:
    comment: Continuous reflector-side capture, group 7.
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_reflector_rx_from_initiator_measurement_7
    type: complex
  states: {}
- name: blocks_file_sink_15
  id: blocks_file_sink
  parameters:
    comment: Continuous initiator-side capture, group 7.
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_initiator_rx_from_reflector_measurement_7
    type: complex
  states: {}
- name: blocks_file_sink_16
  id: blocks_file_sink
  parameters:
    comment: Continuous reflector-side capture, group 8.
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_reflector_rx_from_initiator_measurement_8
    type: complex
  states: {}
- name: blocks_file_sink_17
  id: blocks_file_sink
  parameters:
    comment: Continuous initiator-side capture, group 8.
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_initiator_rx_from_reflector_measurement_8
    type: complex
  states: {}
- name: usrp_ble_capture_gate_2
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate reflector stream for continuous capture group 2.
    group_index: '2'
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_2_0
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate initiator stream for continuous capture group 2.
    group_index: '2'
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_3
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate reflector stream for continuous capture group 3.
    group_index: '3'
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_3_0
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate initiator stream for continuous capture group 3.
    group_index: '3'
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_4
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate reflector stream for continuous capture group 4.
    group_index: '4'
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_4_0
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate initiator stream for continuous capture group 4.
    group_index: '4'
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_5
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate reflector stream for continuous capture group 5.
    group_index: '5'
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_5_0
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate initiator stream for continuous capture group 5.
    group_index: '5'
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_6
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate reflector stream for continuous capture group 6.
    group_index: '6'
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_6_0
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate initiator stream for continuous capture group 6.
    group_index: '6'
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_7
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate reflector stream for continuous capture group 7.
    group_index: '7'
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_7_0
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate initiator stream for continuous capture group 7.
    group_index: '7'
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_8
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate reflector stream for continuous capture group 8.
    group_index: '8'
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_8_0
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate initiator stream for continuous capture group 8.
    group_index: '8'
    num_channels: '1'
  states: {}
- name: usrp_ble_data_store_2
  id: usrp_ble_data_store
  parameters:
    data_len: '200000'
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_reflector_rx_from_initiator_measurement_2
    skip_len: int(0/1000*samp_rate)
  states: {state: disabled}
- name: usrp_ble_data_store_2_0
  id: usrp_ble_data_store
  parameters:
    data_len: '200000'
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_initiator_rx_from_reflector_measurement_2
    skip_len: int(0/1000*samp_rate)
  states: {state: disabled}
- name: usrp_ble_data_store_3
  id: usrp_ble_data_store
  parameters:
    data_len: '200000'
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_reflector_rx_from_initiator_measurement_3
    skip_len: int(0/1000*samp_rate)
  states: {state: disabled}
- name: usrp_ble_data_store_3_0
  id: usrp_ble_data_store
  parameters:
    data_len: '200000'
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_initiator_rx_from_reflector_measurement_3
    skip_len: int(0/1000*samp_rate)
  states: {state: disabled}
- name: usrp_ble_data_store_4
  id: usrp_ble_data_store
  parameters:
    data_len: '200000'
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_reflector_rx_from_initiator_measurement_4
    skip_len: int(0/1000*samp_rate)
  states: {state: disabled}
- name: usrp_ble_data_store_4_0
  id: usrp_ble_data_store
  parameters:
    data_len: '200000'
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_initiator_rx_from_reflector_measurement_4
    skip_len: int(0/1000*samp_rate)
  states: {state: disabled}
- name: usrp_ble_data_store_5
  id: usrp_ble_data_store
  parameters:
    data_len: '200000'
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_reflector_rx_from_initiator_measurement_5
    skip_len: int(0/1000*samp_rate)
  states: {state: disabled}
- name: usrp_ble_data_store_5_0
  id: usrp_ble_data_store
  parameters:
    data_len: '200000'
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_initiator_rx_from_reflector_measurement_5
    skip_len: int(0/1000*samp_rate)
  states: {state: disabled}
- name: usrp_ble_data_store_6
  id: usrp_ble_data_store
  parameters:
    data_len: '200000'
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_reflector_rx_from_initiator_measurement_6
    skip_len: int(0/1000*samp_rate)
  states: {state: disabled}
- name: usrp_ble_data_store_6_0
  id: usrp_ble_data_store
  parameters:
    data_len: '200000'
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_initiator_rx_from_reflector_measurement_6
    skip_len: int(0/1000*samp_rate)
  states: {state: disabled}
- name: usrp_ble_data_store_7
  id: usrp_ble_data_store
  parameters:
    data_len: '200000'
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_reflector_rx_from_initiator_measurement_7
    skip_len: int(0/1000*samp_rate)
  states: {state: disabled}
- name: usrp_ble_data_store_7_0
  id: usrp_ble_data_store
  parameters:
    data_len: '200000'
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_initiator_rx_from_reflector_measurement_7
    skip_len: int(0/1000*samp_rate)
  states: {state: disabled}
- name: usrp_ble_data_store_8
  id: usrp_ble_data_store
  parameters:
    data_len: '200000'
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_reflector_rx_from_initiator_measurement_8
    skip_len: int(0/1000*samp_rate)
  states: {state: disabled}
- name: usrp_ble_data_store_8_0
  id: usrp_ble_data_store
  parameters:
    data_len: '200000'
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_2sides/data_initiator_rx_from_reflector_measurement_8
    skip_len: int(0/1000*samp_rate)
  states: {state: disabled}

connections:
- [analog_sig_source_x_0_1, '0', blocks_multiply_conjugate_cc_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_0_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', usrp_ble_capture_gate_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', usrp_ble_capture_gate_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', usrp_ble_data_store_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', usrp_ble_capture_gate_0_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', usrp_ble_capture_gate_1_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', usrp_ble_data_store_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', usrp_ble_capture_gate_2, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', usrp_ble_capture_gate_2_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', usrp_ble_capture_gate_3, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', usrp_ble_capture_gate_3_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', usrp_ble_capture_gate_4, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', usrp_ble_capture_gate_4_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', usrp_ble_capture_gate_5, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', usrp_ble_capture_gate_5_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', usrp_ble_capture_gate_6, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', usrp_ble_capture_gate_6_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', usrp_ble_capture_gate_7, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', usrp_ble_capture_gate_7_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', usrp_ble_capture_gate_8, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', usrp_ble_capture_gate_8_0, '0']
- [blocks_multiply_xx_0, '0', uhd_usrp_sink_0_0_0, '0']
- [blocks_multiply_xx_0_0, '0', uhd_usrp_sink_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [usrp_ble_capture_gate_0, '0', blocks_file_sink_0, '0']
- [usrp_ble_capture_gate_0_0, '0', blocks_file_sink_0_0, '0']
- [usrp_ble_capture_gate_1, '0', blocks_file_sink_1, '0']
- [usrp_ble_capture_gate_1_0, '0', blocks_file_sink_1_0, '0']
- [usrp_ble_capture_gate_2, '0', blocks_file_sink_4, '0']
- [usrp_ble_capture_gate_2_0, '0', blocks_file_sink_5, '0']
- [usrp_ble_capture_gate_3, '0', blocks_file_sink_6, '0']
- [usrp_ble_capture_gate_3_0, '0', blocks_file_sink_7, '0']
- [usrp_ble_capture_gate_4, '0', blocks_file_sink_8, '0']
- [usrp_ble_capture_gate_4_0, '0', blocks_file_sink_9, '0']
- [usrp_ble_capture_gate_5, '0', blocks_file_sink_10, '0']
- [usrp_ble_capture_gate_5_0, '0', blocks_file_sink_11, '0']
- [usrp_ble_capture_gate_6, '0', blocks_file_sink_12, '0']
- [usrp_ble_capture_gate_6_0, '0', blocks_file_sink_13, '0']
- [usrp_ble_capture_gate_7, '0', blocks_file_sink_14, '0']
- [usrp_ble_capture_gate_7_0, '0', blocks_file_sink_15, '0']
- [usrp_ble_capture_gate_8, '0', blocks_file_sink_16, '0']
- [usrp_ble_capture_gate_8_0, '0', blocks_file_sink_17, '0']
- [usrp_ble_data_send_0, '0', blocks_multiply_xx_0, '1']
- [usrp_ble_data_send_0, '0', usrp_ble_interact_center_0, '0']
- [usrp_ble_data_send_0_0, '0', blocks_multiply_xx_0_0, '1']
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_0, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_0_0, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_1, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_1_0, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_2, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_2_0, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_3, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_3_0, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_4, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_4_0, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_5, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_5_0, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_6, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_6_0, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_7, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_7_0, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_8, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_8_0, command]
- [usrp_ble_interact_center_0, freq_ctrl, analog_sig_source_x_0_1, cmd]
- [usrp_ble_interact_center_0, freq_ctrl, blocks_message_debug_0, print]
- [usrp_ble_interact_center_0, send1_ctrl, usrp_ble_data_send_0, command]
- [usrp_ble_interact_center_0, send2_ctrl, usrp_ble_data_send_0_0, command]
- [usrp_ble_interact_center_0, store1_ctrl, usrp_ble_data_store_0, command]
- [usrp_ble_interact_center_0, store2_ctrl, usrp_ble_data_store_0_0, command]

metadata:
  file_format: 1
