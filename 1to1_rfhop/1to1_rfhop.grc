options:
  parameters:
    author: lfy
    comment: Low-rate RF center-frequency hopping, no TX/RX gate.
    generate_options: qt_gui
    id: ble_cs_1to1_rfhop_nogate
    output_language: python
    title: BLE CS 1to1 RF-hop no-gate
  states: {}

blocks:
- name: centetr_fre
  id: variable
  parameters:
    value: 2.44e9 + hop_offset - tone_freq
  states: {}
- name: display_decim
  id: variable
  parameters:
    value: '1'
  states: {}
- name: hop_offset
  id: variable
  parameters:
    comment: Updated from interact_center freq_ctrl; RF center = 2.44 GHz + hop_offset - tone_freq
    value: '-40e6'
  states: {}
- name: recv_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: send_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: start_button
  id: variable_qtgui_push_button
  parameters:
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: stop_button
  id: variable_qtgui_push_button
  parameters:
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: tone_freq
  id: variable
  parameters:
    comment: Fixed low-rate baseband tone. RF tone = USRP center + tone_freq.
    value: 100e3
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: tone_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    showports: 'True'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: hop_offset
    offset: '0'
    phase: '0'
    samp_rate: 100e6
    showports: 'True'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_rfhop/data_reflector_rx_from_initiator2
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_rfhop/data_initiator_rx_from_reflector2
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_msgpair_to_var_hop_offset
  id: blocks_msgpair_to_var
  parameters:
    target: hop_offset
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/display_decim
    fc: '0'
    fftsize: '8192'
    name: '"rx_gate"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 100e6
    fc: '0'
    fftsize: '8192'
    name: '"rx_gate"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: 5e6
    center_freq0: centetr_fre
    dev_addr: '"addr=192.168.30.2"'
    dev_args: '"send_frame_size=8000,num_send_frames=512"'
    gain0: send_gain
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_0_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: centetr_fre
    center_freq1: centetr_fre
    dev_addr: '"addr=192.168.40.2"'
    dev_args: '"send_frame_size=8000,num_send_frames=512"'
    gain0: send_gain
    gain1: send_gain
    nchan: '2'
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: centetr_fre
    dev_addr: '"addr=192.168.30.2"'
    dev_args: '"recv_frame_size=8000,num_recv_frames=512"'
    gain0: recv_gain
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: centetr_fre
    center_freq1: centetr_fre
    dev_addr: '"addr=192.168.40.2"'
    dev_args: '"recv_frame_size=8000,num_recv_frames=512"'
    gain0: recv_gain
    gain1: recv_gain
    nchan: '2'
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: sync
    type: fc32
  states: {}
- name: usrp_ble_capture_gate_0
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate reflector stream before file sink.
    group_index: '0'
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_0_0
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate initiator stream before file sink.
    group_index: '0'
    num_channels: '1'
  states: {}
- name: usrp_ble_data_send_0
  id: usrp_ble_data_send
  parameters:
    bit_duration: '0.001'
    sample_rate: samp_rate
  states: {}
- name: usrp_ble_data_send_0_0
  id: usrp_ble_data_send
  parameters:
    bit_duration: '0.001'
    sample_rate: samp_rate
  states: {}
- name: usrp_ble_data_store_0
  id: usrp_ble_data_store
  parameters:
    data_len: '2000'
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_rfhop/data_reflector_rx_from_initiator
    skip_len: '2500'
  states: {state: disabled}
- name: usrp_ble_data_store_0_0
  id: usrp_ble_data_store
  parameters:
    data_len: '2000'
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1_rfhop/data_initiator_rx_from_reflector
    skip_len: '2500'
  states: {state: disabled}
- name: usrp_ble_interact_center_rfhop_0
  id: usrp_ble_interact_center_rfhop
  parameters:
    repeat_total: '3'
    sample_rate: int(samp_rate)
    settle_time_ms: '30'
    start_btn: start_button
    start_freq_index: '-40'
    step_hz: '1'
    stop_btn: stop_button
    stop_freq_index: '40'
    wait_time_ms: '10'
  states: {}
- name: usrp_ble_random_phase_0
  id: usrp_ble_random_phase
  parameters:
    amplitude: '1.0'
    seed: '1'
  states: {state: disabled}
- name: usrp_ble_random_phase_1
  id: usrp_ble_random_phase
  parameters:
    amplitude: '1.0'
    seed: '2'
  states: {state: disabled}

connections:
- [analog_sig_source_x_0_1, '0', blocks_multiply_conjugate_cc_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_0_1, '0', usrp_ble_random_phase_1, '0']
- [analog_sig_source_x_0_1_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', usrp_ble_capture_gate_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', usrp_ble_data_store_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', usrp_ble_capture_gate_0_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', usrp_ble_data_store_0_0, '0']
- [blocks_multiply_xx_0, '0', uhd_usrp_sink_0_0_0_0, '0']
- [blocks_multiply_xx_0_0, '0', uhd_usrp_sink_0_0_0_0, '1']
- [uhd_usrp_source_0_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [uhd_usrp_source_0_0, '1', blocks_multiply_conjugate_cc_0, '0']
- [uhd_usrp_source_0_0, '1', qtgui_freq_sink_x_0_1, '0']
- [usrp_ble_capture_gate_0, '0', blocks_file_sink_0, '0']
- [usrp_ble_capture_gate_0_0, '0', blocks_file_sink_0_0, '0']
- [usrp_ble_data_send_0, '0', blocks_multiply_xx_0, '1']
- [usrp_ble_data_send_0, '0', usrp_ble_interact_center_rfhop_0, '0']
- [usrp_ble_data_send_0_0, '0', blocks_multiply_xx_0_0, '1']
- [usrp_ble_interact_center_rfhop_0, capture_ctrl, usrp_ble_capture_gate_0, command]
- [usrp_ble_interact_center_rfhop_0, capture_ctrl, usrp_ble_capture_gate_0_0, command]
- [usrp_ble_interact_center_rfhop_0, freq_ctrl, blocks_message_debug_0, print]
- [usrp_ble_interact_center_rfhop_0, freq_ctrl, blocks_msgpair_to_var_hop_offset, inpair]
- [usrp_ble_interact_center_rfhop_0, freq_ctrl, usrp_ble_random_phase_0, freq]
- [usrp_ble_interact_center_rfhop_0, freq_ctrl, usrp_ble_random_phase_1, freq]
- [usrp_ble_interact_center_rfhop_0, send1_ctrl, usrp_ble_data_send_0, command]
- [usrp_ble_interact_center_rfhop_0, send2_ctrl, usrp_ble_data_send_0_0, command]
- [usrp_ble_interact_center_rfhop_0, store1_ctrl, usrp_ble_data_store_0, command]
- [usrp_ble_interact_center_rfhop_0, store2_ctrl, usrp_ble_data_store_0_0, command]
- [usrp_ble_random_phase_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [usrp_ble_random_phase_0, '0', blocks_multiply_xx_0, '0']
- [usrp_ble_random_phase_1, '0', blocks_multiply_conjugate_cc_0, '1']
- [usrp_ble_random_phase_1, '0', blocks_multiply_xx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
