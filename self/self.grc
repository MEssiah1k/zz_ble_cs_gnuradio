options:
  parameters:
    generate_options: qt_gui
    id: ble_cs_self
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: centetr_fre
  id: variable
  parameters:
    value: 2.44e9
  states: {}
- name: distance_m
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: start_button
  id: variable_qtgui_push_button
  parameters:
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: stop_button
  id: variable_qtgui_push_button
  parameters:
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-40e5'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    showports: 'True'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Continuous reflector-side capture.
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1/data_reflector_rx_from_initiator2
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    comment: Continuous initiator-side capture.
    file: /home/lfy/workarea/zz_ble_cs_gnuradio/1to1/data_initiator_rx_from_reflector2
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_1_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: usrp_ble_capture_gate_0
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate reflector stream before continuous file sink.
    num_channels: '1'
  states: {}
- name: usrp_ble_capture_gate_0_0
  id: usrp_ble_capture_gate
  parameters:
    comment: Gate initiator stream before continuous file sink.
    num_channels: '1'
  states: {}
- name: usrp_ble_channel_phase_0
  id: usrp_ble_channel_phase
  parameters:
    amplitude: '1.0'
    center_freq_hz: centetr_fre
    distance_m: distance_m
  states: {}
- name: usrp_ble_channel_phase_1
  id: usrp_ble_channel_phase
  parameters:
    amplitude: '1.0'
    center_freq_hz: centetr_fre
    distance_m: distance_m
  states: {}
- name: usrp_ble_data_send_0
  id: usrp_ble_data_send
  parameters:
    bit_duration: '0.001'
    sample_rate: samp_rate
  states: {}
- name: usrp_ble_data_send_0_0
  id: usrp_ble_data_send
  parameters:
    bit_duration: '0.001'
    sample_rate: samp_rate
  states: {}
- name: usrp_ble_data_store_0_0_0
  id: usrp_ble_data_store
  parameters:
    data_len: '200'
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/self/data_initiator_rx_from_reflector
    skip_len: '50000'
  states: {state: disabled}
- name: usrp_ble_data_store_0_1
  id: usrp_ble_data_store
  parameters:
    data_len: '200'
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/self/data_reflector_rx_from_initiator
    skip_len: '35000'
  states: {state: disabled}
- name: usrp_ble_interact_center_0
  id: usrp_ble_interact_center
  parameters:
    repeat_total: '2'
    sample_rate: int(samp_rate)
    settle_time_ms: '0.0'
    start_btn: start_button
    start_freq_index: '-40'
    step_hz: 1e5
    stop_btn: stop_button
    stop_freq_index: '40'
    store_lead_ms: '0'
    use_msg_clock: 'False'
    wait_time_ms: '100'
  states: {}
- name: usrp_ble_random_phase_0
  id: usrp_ble_random_phase
  parameters:
    amplitude: '1.0'
    seed: '1'
  states: {state: disabled}
- name: usrp_ble_random_phase_1
  id: usrp_ble_random_phase
  parameters:
    amplitude: '1.0'
    seed: '2'
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_1_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_multiply_conjugate_cc_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_0_1, '0', usrp_ble_random_phase_0, '0']
- [analog_sig_source_x_0_1, '0', usrp_ble_random_phase_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', usrp_ble_capture_gate_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', usrp_ble_data_store_0_1, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', usrp_ble_capture_gate_0_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', usrp_ble_data_store_0_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', usrp_ble_channel_phase_0, '0']
- [blocks_multiply_xx_0_0, '0', usrp_ble_channel_phase_1, '0']
- [blocks_throttle2_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_throttle2_1, '0', blocks_multiply_xx_0, '1']
- [blocks_throttle2_1_0, '0', usrp_ble_interact_center_0, '0']
- [usrp_ble_capture_gate_0, '0', blocks_file_sink_0, '0']
- [usrp_ble_capture_gate_0_0, '0', blocks_file_sink_0_0, '0']
- [usrp_ble_channel_phase_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [usrp_ble_channel_phase_1, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [usrp_ble_data_send_0, '0', blocks_throttle2_1, '0']
- [usrp_ble_data_send_0_0, '0', blocks_throttle2_0, '0']
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_0, command]
- [usrp_ble_interact_center_0, capture_ctrl, usrp_ble_capture_gate_0_0, command]
- [usrp_ble_interact_center_0, freq_ctrl, analog_sig_source_x_0_1, cmd]
- [usrp_ble_interact_center_0, freq_ctrl, blocks_message_debug_0, print]
- [usrp_ble_interact_center_0, freq_ctrl, usrp_ble_channel_phase_0, freq]
- [usrp_ble_interact_center_0, freq_ctrl, usrp_ble_channel_phase_1, freq]
- [usrp_ble_interact_center_0, freq_ctrl, usrp_ble_random_phase_0, freq]
- [usrp_ble_interact_center_0, freq_ctrl, usrp_ble_random_phase_1, freq]
- [usrp_ble_interact_center_0, send1_ctrl, usrp_ble_data_send_0, command]
- [usrp_ble_interact_center_0, send2_ctrl, usrp_ble_data_send_0_0, command]
- [usrp_ble_interact_center_0, store1_ctrl, usrp_ble_data_store_0_1, command]
- [usrp_ble_interact_center_0, store2_ctrl, usrp_ble_data_store_0_0_0, command]
- [usrp_ble_random_phase_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [usrp_ble_random_phase_0, '0', blocks_multiply_xx_0, '0']
- [usrp_ble_random_phase_1, '0', blocks_multiply_conjugate_cc_0, '1']
- [usrp_ble_random_phase_1, '0', blocks_multiply_xx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
