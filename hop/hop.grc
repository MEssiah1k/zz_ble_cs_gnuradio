options:
  parameters:
    author: lfy
    generate_options: qt_gui
    id: hop
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: centetr_fre
  id: variable
  parameters:
    value: 2.44e9
  states: {}
- name: recv_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: send_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: start_button
  id: variable_qtgui_push_button
  parameters:
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: stop_button
  id: variable_qtgui_push_button
  parameters:
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: 500e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '-500e3'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-40e6'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    showports: 'True'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: 10e3
    center_freq0: centetr_fre
    dev_addr: '"addr=192.168.30.2"'
    dev_args: '"recv_frame_size=8000"'
    gain0: send_gain
    len_tag_name: ''
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_0_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: centetr_fre
    center_freq1: centetr_fre
    dev_addr: '"addr=192.168.30.2"'
    dev_args: '"send_frame_size=8000,num_send_frames=512"'
    gain0: send_gain
    gain1: send_gain
    len_tag_name: ''
    nchan: '2'
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_0_0_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: centetr_fre
    dev_addr: '"addr=192.168.30.2"'
    dev_args: '"send_frame_size=8000,num_send_frames=512"'
    gain0: send_gain
    len_tag_name: ''
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: centetr_fre
    dev_addr: '"addr=192.168.30.2"'
    dev_args: '"recv_frame_size=8000"'
    gain0: recv_gain
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: centetr_fre
    center_freq1: centetr_fre
    dev_addr: '"addr=192.168.30.2"'
    dev_args: '"recv_frame_size=8000,num_recv_frames=512"'
    gain0: recv_gain
    gain1: recv_gain
    nchan: '2'
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: none
    type: fc32
  states: {state: disabled}
- name: usrp_ble_data_send_0
  id: usrp_ble_data_send
  parameters:
    bit_duration: '0.001'
    sample_rate: samp_rate
  states: {state: disabled}
- name: usrp_ble_data_send_0_0
  id: usrp_ble_data_send
  parameters:
    bit_duration: '0.001'
    sample_rate: samp_rate
  states: {}
- name: usrp_ble_data_store_0
  id: usrp_ble_data_store
  parameters:
    data_len: '200'
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/hop/data_store_2
    skip_len: '30000'
  states: {state: disabled}
- name: usrp_ble_data_store_0_0
  id: usrp_ble_data_store
  parameters:
    data_len: '200'
    path: /home/lfy/workarea/zz_ble_cs_gnuradio/hop/data_store_1
    skip_len: '30000'
  states: {state: disabled}
- name: usrp_ble_interact_center_0
  id: usrp_ble_interact_center
  parameters:
    repeat_total: '1'
    sample_rate: int(samp_rate)
    start_btn: start_button
    stop_btn: stop_button
    wait_time_ms: '1000.0'
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_1, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0_1, '1']
- [blocks_multiply_xx_0, '0', uhd_usrp_sink_0_0_0_0, '1']
- [blocks_multiply_xx_0_0, '0', uhd_usrp_sink_0_0_0_0, '0']
- [blocks_multiply_xx_0_0, '0', uhd_usrp_sink_0_0_0_0_0, '0']
- [blocks_multiply_xx_0_1, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_xx_0_1, '0', blocks_multiply_xx_0_0, '0']
- [uhd_usrp_source_0_0, '0', usrp_ble_data_store_0_0, '0']
- [uhd_usrp_source_0_0, '1', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0_0, '1', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0_0, '1', usrp_ble_data_store_0, '0']
- [usrp_ble_data_send_0, '0', blocks_multiply_xx_0, '1']
- [usrp_ble_data_send_0, '0', usrp_ble_interact_center_0, '0']
- [usrp_ble_data_send_0_0, '0', blocks_multiply_xx_0_0, '1']
- [usrp_ble_interact_center_0, freq_ctrl, analog_sig_source_x_0_1, cmd]
- [usrp_ble_interact_center_0, freq_ctrl, blocks_message_debug_0, print]
- [usrp_ble_interact_center_0, send1_ctrl, usrp_ble_data_send_0, command]
- [usrp_ble_interact_center_0, send2_ctrl, usrp_ble_data_send_0_0, command]
- [usrp_ble_interact_center_0, store1_ctrl, usrp_ble_data_store_0_0, command]
- [usrp_ble_interact_center_0, store2_ctrl, usrp_ble_data_store_0, command]

metadata:
  file_format: 1
  grc_version: 3.10.7.0
